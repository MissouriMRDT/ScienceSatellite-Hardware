# Repository MissouriMRDT/ScienceSatellite-Hardware

## KiCad design Sattelite Board/Sattelite Board.kicad_pcb

Parts:
R1, R2: 19.3K; R_0603_HandSoldering
R3, R4: 10K; R_0603_HandSoldering
R5: 100K; R_0603_HandSoldering
U1: MQ-4; MQ-4-Breakout
U2: MQ-135-Breakout
U3: HIH-4030-Breakout
U4: TMP36; TMP36-Breakout
U5: GY-ML8511-Breakout
U6: MPL3115A2-Breakout
U7: Molex_SL-10; MOLEX_SL_10

Connections:
+3V3: R5.1, U4.1 (+3V3), U5.1 (3V3), U6.5 (3V3), U7.1
+5V: U1.1 (+5V), U2.1 (+5V), U3.1 (+5V), U7.2
Ammonia_VOUT: R1.2, R3.2, U7.5
GND: R1.1, R2.1, U1.3 (GND), U2.3 (GND), U3.3 (GND), U4.3 (GND), U5.2 (GND), U6.6 (GND), U7.3
Humidity_VOUT: R2.2, R4.2, U7.7
Methane_VOUT: U1.2 (Aout), U7.4
unnamed: R3.1, U2.2 (Aout)
unnamed: R4.1, U3.2 (Out)
unnamed: R5.2, U5.4 (EN)
unnamed: U6.1 (INT2), U6.2 (INT1)
Pressure_SCL: U6.4 (SCL), U7.9
Pressure_SDA: U6.3 (SDA), U7.10
Temp_VOUT: U4.2 (Vout), U7.8
UV_VOUT: U5.3 (OUT), U7.6

Notes on the sheet:
Sensors
Methane
Connector
Ammonia
Humidity
Temperature
UltraViolet
Pressure

Board: 2 copper layers, 44.7 x 69.1 mm, 12 parts (0 on the bottom side), 14 nets.

## KiCad design Sattelite Board/MQ-4_Breakout.kicad_pcb

Board: 2 copper layers, 21.8 x 17.3 mm, 4 parts (0 on the bottom side), 4 nets.

Parts:
J1: Conn_01x03; 3x1_Header
R1: 19.3k; R_0603_HandSoldering
R2: 10k; R_0603_HandSoldering
U1: MQ-4

Connections:
/+5V: J1.3, U1.1
/A_OUT: J1.2, R1.2, R2.2
/GND: J1.1, R1.1, U1.3
unnamed: R2.1, U1.2

## Commit log

2018-03-10 Created sensor breakout boards and attelite schematic
2018-03-11 Finished rev 1 board
2018-03-17 Final Touches before Bard Review
2018-03-20 Created Gerbs
